# Keil uVision project SPI.uvprojx, settings and files
target SPI (ARM-ADS)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x00200000) IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPI +hex
  c flags: Optim=1
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\SPI;..\FWLIB\inc;..\HARDWARE\MATH;..\HARDWARE\MPU6000;..\HARDWARE\SPI;..\HARDWARE\MPU6500;..\HARDWARE\L3GD20;..\HARDWARE\LSM303D
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/MATH/: mathTool.c vector3.c
    ../HARDWARE/MPU6000/: mpu6000.c
    ../HARDWARE/SPI/: drv_spi.c
    ../HARDWARE/MPU6500/: mpu6500.c
    ../HARDWARE/L3GD20/: L3GD20.c
    ../HARDWARE/LSM303D/: LSM303.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f427_437xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group README
    ../: readme.txt
